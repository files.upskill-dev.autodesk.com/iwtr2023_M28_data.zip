[VERSION]
3

[TITLE]

[JUNCTIONS]
10  0	60.000000	28.960000	1
100  0	55.000000	14.063000	1
102  0	55.000000	15.170000	1
104  0	55.000000	11.389000	1
106  0	55.000000
108  0	55.000000
11  0	60.000000
110  0	55.000000	3.004000	1
112  0	55.000000	15.871000	1
114  0	55.000000
116  0	55.000000	8.858000	1
118  0	55.000000	9.047000	1
12  0	60.000000
120  0	55.000000
122  0	55.000000
124  0	54.000000
126  0	54.000000
128  0	55.000000	5.528000	1
130  0	55.000000	5.079000	1
132  0	56.000000
134  0	55.000000	5.119000	1
136  0	55.000000	30.647000	1
138  0	54.000000	11.744000	1
14  0	59.000000	7.786000	1
140  0	56.000000
142  0	55.000000	13.102000	1
144  0	55.000000
146  0	55.000000	14.896000	1
148  0	54.000000	5.729000	1
150  0	56.000000
152  0	55.000000	12.971000	1
154  0	55.000000	17.532000	1
156  0	54.000000
158  0	53.000000	9.129000	1
16  0	59.000000	1.962000	1
160  0	54.000000	9.024000	1
162  0	53.000000	11.767000	1
164  0	53.000000
166  0	53.000000
168  0	54.000000	6.714000	1
170  0	54.000000
172  0	53.000000	14.756000	1
174  0	53.000000
176  0	55.000000
178  0	55.000000	10.686000	1
18  0	58.000000	9.012000	1
180  0	55.000000	11.854000	1
182  0	53.000000
184  0	55.000000	8.436000	1
186  0	54.000000
188  0	0.000000
190  0	54.000000
192  0	53.000000	11.408000	1
194  0	54.000000
196  0	54.000000	17.927000	1
198  0	53.000000
2  0	61.000000
20  0	57.000000	10.080000	1
200  0	53.000000
202  0	50.000000	5.716000	1
204  0	50.000000	16.294000	1
206  0	50.000000
208  0	52.000000	1.634000	1
21  0	61.000000
210  0	51.000000
212  0	51.000000
214  0	53.000000
216  0	53.000000
218  0	52.000000	12.773000	1
22  0	61.000000
220  0	53.000000
222  0	53.000000
224  0	53.000000	11.530000	1
226  0	51.000000
227  0	51.000000
228  0	51.000000
230  0	51.000000	20.626000	1
232  0	52.000000
234  0	52.000000
236  0	52.000000
238  0	53.000000
24  0	60.000000
240  0	53.000000	13.419000	1
242  0	52.000000
244  0	50.000000
246  0	50.000000
250  0	57.000000	4.051000	1
252  0	55.000000	13.024000	1
256  0	57.000000
258  0	55.000000	11.046000	1
26  0	58.000000
260  0	56.000000
262  0	55.000000
264  0	55.000000
266  0	56.000000
268  0	55.000000	8.120000	1
270  0	55.000000
272  0	55.000000
274  0	55.000000
276  0	55.000000	11.582000	1
278  0	55.000000
280  0	55.000000
282  0	56.000000
286  0	55.000000
288  0	56.000000
290  0	55.000000	6.872000	1
292  0	55.000000
294  0	54.000000	10.028000	1
296  0	55.000000
298  0	55.000000	11.020000	1
30  0	58.000000
300  0	55.000000
302  0	55.000000
304  0	55.000000
306  0	55.000000	9.860000	1
308  0	54.000000	4.298000	1
310  0	54.000000
312  0	54.000000
314  0	54.000000	14.236000	1
316  0	54.000000
32  0	60.000000	8.960000	1
320  0	54.000000	9.256000	1
322  0	55.000000
324  0	54.000000
326  0	55.000000
328  0	55.000000
330  0	55.000000	15.387000	1
332  0	55.000000
334  0	55.000000
336  0	55.000000
338  0	54.000000	15.906000	1
34  0	60.000000	10.677000	1
340  0	54.000000	9.412000	1
342  0	53.000000	10.186000	1
344  0	55.000000
346  0	54.000000	17.434000	1
348  0	53.000000
350  0	53.000000	17.584000	1
352  0	54.000000
354  0	54.000000	12.760000	1
356  0	54.000000	7.733000	1
358  0	55.000000	21.784000	1
36  0	58.000000
360  0	55.000000
362  0	55.000000
364  0	55.000000	16.142000	1
366  0	55.000000
368  0	55.000000	7.838000	1
370  0	55.000000	12.636000	1
372  0	54.000000
374  0	53.000000	22.833000	1
376  0	52.000000
378  0	53.000000	9.227000	1
38  0	56.000000	8.849000	1
380  0	53.000000
382  0	52.000000
384  0	52.000000	11.804000	1
386  0	52.000000
388  0	51.000000
390  0	51.000000
392  0	53.000000	19.958000	1
394  0	53.000000	7.654000	1
396  0	53.000000	11.161000	1
398  0	51.000000	22.364000	1
4  0	61.000000	36.224000	1
40  0	56.000000	3.428000	1
400  0	52.000000
402  0	51.000000
404  0	54.000000
406  0	54.000000	17.173000	1
408  0	52.000000
410  0	52.000000	8.220000	1
412  0	50.000000	11.943000	1
414  0	50.000000
416  0	50.000000
418  0	50.000000
42  0	58.000000
420  0	50.000000
422  0	50.000000
424  0	49.000000	24.737000	1
426  0	49.000000
428  0	48.000000
430  0	53.000000	19.247000	1
432  0	52.000000	7.007000	1
434  0	52.000000
436  0	52.000000
438  0	52.000000	12.356000	1
44  0	57.000000
440  0	53.000000
442  0	53.000000	12.962000	1
444  0	52.000000	4.852000	1
446  0	52.000000
448  0	52.000000	8.726000	1
450  0	52.000000	3.243000	1
452  0	51.000000	8.269000	1
454  0	51.000000
456  0	51.000000	15.217000	1
458  0	51.000000
46  0	57.000000	16.112000	1
460  0	51.000000
462  0	51.000000
464  0	51.000000
466  0	51.000000	4.842000	1
468  0	51.000000	12.180000	1
470  0	50.000000	8.059000	1
472  0	50.000000	16.108000	1
474  0	51.000000	4.830000	1
476  0	50.000000
478  0	50.000000
48  0	56.000000
480  0	50.000000	4.086000	1
484  0	50.000000
486  0	50.000000
490  0	49.000000
50  0	56.000000	11.989000	1
52  0	56.000000
54  0	56.000000
56  0	58.000000
58  0	58.000000	7.512000	1
6  0	60.000000	12.074000	1
60  0	56.000000
62  0	58.000000	7.344000	1
64  0	58.000000	3.682000	1
66  0	58.000000	8.094000	1
68  0	58.000000	21.194000	1
70  0	57.000000
72  0	57.000000
74  0	57.000000
76  0	57.000000
78  0	56.000000	13.727000	1
8  0	60.000000	14.417000	1
80  0	56.000000	1.980000	1
82  0	55.000000	5.063000	1
84  0	58.000000
86  0	58.000000
88  0	57.000000	15.148000	1
90  0	55.000000
92  0	57.000000
94  0	56.000000	7.206000	1
96  0	55.000000
98  0	56.000000
SURGETANK5018  0	55.000000
SURGETANK5020  0	55.000000
SURGETANK5025  0	54.000000
~$$_UDF_HN_0_0  0    0.0
~$$_UDF_CN_0_0  0    0.0
~$$_UDF_HN_0_1  0    0.0
~$$_UDF_CN_0_1  0    0.0
~$$_UDF_HN_0_2  0    0.0
~$$_UDF_CN_0_2  0    0.0
~$$_UDF_HN_1_0  0    0.0
~$$_UDF_CN_1_0  0    0.0
~$$_UDF_HN_1_1  0    0.0
~$$_UDF_CN_1_1  0    0.0
~$$_UDF_HN_1_2  0    0.0
~$$_UDF_CN_1_2  0    0.0
~$$_UDF_HN_2_0  0    0.0
~$$_UDF_CN_2_0  0    0.0
~$$_UDF_HN_2_1  0    0.0
~$$_UDF_CN_2_1  0    0.0
~$$_UDF_HN_2_2  0    0.0
~$$_UDF_CN_2_2  0    0.0
5018_NU  1	60.000000
5018_ND  1	60.000000
5020_NU  1	55.000000
5020_ND  1	55.000000
5025_NU  1	54.000000
5025_ND  1	54.000000
5028_NU  1	50.000000
5028_ND  1	50.000000

[RESERVOIRS]
28	0	-54.000000	-
284	0	-83.000000	-
318	0	-92.000000	-
482	0	-61.000000	-

[TANKS]

[PIPES]
10	190	188	0	-	-	281.000000	6.000000	118.000000	0.000000	0	0
100	26	24	0	-	-	606.000000	6.000000	97.000000	0.000000	0	0
102	22	32	0	-	-	527.000000	6.000000	97.000000	0.000000	0	0
104	4	22	0	-	-	431.000000	6.000000	97.000000	0.000000	0	0
106	21	22	0	-	-	123.000000	4.000000	97.000000	0.000000	0	0
108	42	26	0	-	-	270.000000	8.000000	100.000000	0.000000	0	0
110	26	6	0	-	-	247.000000	8.000000	100.000000	0.000000	0	0
112	2	4	0	-	-	418.000000	10.000000	100.000000	0.000000	0	0
114	4	6	0	-	-	637.000000	10.000000	100.000000	0.000000	0	0
116	8	6	0	-	-	375.000000	10.000000	100.000000	0.000000	0	0
118	200	202	0	-	-	1356.000000	10.000000	118.000000	0.000000	0	0
12	196	190	0	-	-	290.000000	8.000000	118.000000	0.000000	0	0
120	202	204	0	-	-	228.000000	10.000000	118.000000	0.000000	0	0
122	204	206	0	-	-	353.000000	4.000000	114.000000	0.000000	0	0
124	202	244	0	-	-	401.000000	10.000000	118.000000	0.000000	0	0
126	244	246	0	-	-	365.000000	4.000000	114.000000	0.000000	0	0
128	204	208	0	-	-	709.000000	10.000000	118.000000	0.000000	0	0
130	208	214	0	-	-	248.000000	10.000000	118.000000	0.000000	0	0
132	214	182	0	-	-	418.000000	10.000000	113.000000	0.000000	0	0
134	182	224	0	-	-	139.000000	10.000000	113.000000	0.000000	0	0
136	214	216	0	-	-	156.000000	8.000000	112.000000	0.000000	0	0
138	216	218	0	-	-	200.000000	8.000000	112.000000	0.000000	0	0
14	198	192	0	-	-	311.000000	8.000000	118.000000	0.000000	0	0
140	218	220	0	-	-	416.000000	8.000000	112.000000	0.000000	0	0
142	220	222	0	-	-	298.000000	8.000000	112.000000	0.000000	0	0
144	216	222	0	-	-	350.000000	8.000000	112.000000	0.000000	0	0
146	210	212	0	-	-	158.000000	6.000000	119.000000	0.000000	0	0
148	208	210	0	-	-	298.000000	8.000000	119.000000	0.000000	0	0
150	210	230	0	-	-	144.000000	8.000000	119.000000	0.000000	0	0
152	230	226	0	-	-	152.000000	8.000000	119.000000	0.000000	0	0
154	226	227	0	-	-	116.000000	6.000000	119.000000	0.000000	0	0
156	226	228	0	-	-	118.000000	8.000000	119.000000	0.000000	0	0
158	228	232	0	-	-	236.000000	8.000000	119.000000	0.000000	0	0
16	192	186	0	-	-	265.000000	8.000000	118.000000	0.000000	0	0
160	232	240	0	-	-	333.000000	8.000000	118.000000	0.000000	0	0
162	228	236	0	-	-	304.000000	6.000000	119.000000	0.000000	0	0
164	232	234	0	-	-	238.000000	6.000000	118.000000	0.000000	0	0
166	232	238	0	-	-	372.000000	6.000000	118.000000	0.000000	0	0
168	224	240	0	-	-	598.000000	8.000000	110.000000	0.000000	0	0
170	240	242	0	-	-	374.000000	8.000000	110.000000	0.000000	0	0
172	224	148	0	-	-	480.000000	10.000000	113.000000	0.000000	0	0
174	148	138	0	-	-	386.000000	10.000000	113.000000	0.000000	0	0
176	242	174	0	-	-	255.000000	8.000000	108.000000	0.000000	0	0
178	162	158	0	-	-	307.000000	6.000000	105.000000	0.000000	0	0
18	186	184	0	-	-	669.000000	8.000000	114.000000	0.000000	0	0
180	162	166	0	-	-	284.000000	6.000000	105.000000	0.000000	0	0
182	166	174	0	-	-	334.000000	6.000000	108.000000	0.000000	0	0
184	148	158	0	-	-	512.000000	10.000000	110.000000	0.000000	0	0
186	158	160	0	-	-	461.000000	10.000000	110.000000	0.000000	0	0
188	166	164	0	-	-	248.000000	6.000000	105.000000	0.000000	0	0
190	170	164	0	-	-	484.000000	6.000000	108.000000	0.000000	0	0
192	164	172	0	-	-	339.000000	6.000000	108.000000	0.000000	0	0
194	174	172	0	-	-	256.000000	8.000000	108.000000	0.000000	0	0
196	172	170	0	-	-	251.000000	8.000000	108.000000	0.000000	0	0
198	170	168	0	-	-	163.000000	8.000000	108.000000	0.000000	0	0
2	200	198	0	-	-	300.000000	8.000000	118.000000	0.000000	0	0
20	184	176	0	-	-	418.000000	8.000000	114.000000	0.000000	0	0
200	138	100	0	-	-	721.000000	10.000000	113.000000	0.000000	0	0
202	54	100	0	-	-	706.000000	10.000000	113.000000	0.000000	0	0
204	54	46	0	-	-	480.000000	10.000000	113.000000	0.000000	0	0
206	46	48	0	-	-	164.000000	6.000000	108.000000	0.000000	0	0
208	46	44	0	-	-	280.000000	10.000000	113.000000	0.000000	0	0
210	44	42	0	-	-	335.000000	8.000000	100.000000	0.000000	0	0
212	48	50	0	-	-	519.000000	6.000000	108.000000	0.000000	0	0
214	50	54	0	-	-	189.000000	6.000000	108.000000	0.000000	0	0
216	50	52	0	-	-	158.000000	4.000000	108.000000	0.000000	0	0
218	52	96	0	-	-	80.000000	4.000000	108.000000	0.000000	0	0
22	176	178	0	-	-	327.000000	8.000000	110.000000	0.000000	0	0
220	52	98	0	-	-	188.000000	4.000000	108.000000	0.000000	0	0
222	168	160	0	-	-	326.000000	10.000000	110.000000	0.000000	0	0
224	124	160	0	-	-	218.000000	10.000000	110.000000	0.000000	0	0
226	124	126	0	-	-	556.000000	6.000000	105.000000	0.000000	0	0
228	124	112	0	-	-	260.000000	10.000000	110.000000	0.000000	0	0
230	112	106	0	-	-	272.000000	10.000000	110.000000	0.000000	0	0
232	106	104	0	-	-	253.000000	10.000000	110.000000	0.000000	0	0
234	110	112	0	-	-	310.000000	6.000000	105.000000	0.000000	0	0
236	112	114	0	-	-	556.000000	6.000000	105.000000	0.000000	0	0
238	106	108	0	-	-	560.000000	6.000000	105.000000	0.000000	0	0
24	178	180	0	-	-	361.000000	8.000000	110.000000	0.000000	0	0
240	102	110	0	-	-	466.000000	6.000000	105.000000	0.000000	0	0
242	54	60	0	-	-	519.000000	8.000000	108.000000	0.000000	0	0
244	60	102	0	-	-	276.000000	6.000000	108.000000	0.000000	0	0
246	102	104	0	-	-	245.000000	10.000000	110.000000	0.000000	0	0
248	60	82	0	-	-	776.000000	10.000000	110.000000	0.000000	0	0
250	44	56	0	-	-	416.000000	8.000000	100.000000	0.000000	0	0
252	56	58	0	-	-	436.000000	8.000000	100.000000	0.000000	0	0
254	58	62	0	-	-	327.000000	8.000000	119.000000	0.000000	0	0
256	56	11	0	-	-	635.000000	6.000000	100.000000	0.000000	0	0
258	11	10	0	-	-	123.000000	6.000000	100.000000	0.000000	0	0
26	180	186	0	-	-	337.000000	8.000000	110.000000	0.000000	0	0
260	8	10	0	-	-	576.000000	10.000000	100.000000	0.000000	0	0
262	10	12	0	-	-	226.000000	10.000000	100.000000	0.000000	0	0
266	12	14	0	-	-	317.000000	10.000000	122.000000	0.000000	0	0
268	14	16	0	-	-	162.000000	10.000000	122.000000	0.000000	0	0
270	16	18	0	-	-	273.000000	10.000000	122.000000	0.000000	0	0
272	62	14	0	-	-	576.000000	8.000000	119.000000	0.000000	0	0
274	64	16	0	-	-	568.000000	8.000000	119.000000	0.000000	0	0
276	62	64	0	-	-	161.000000	8.000000	119.000000	0.000000	0	0
278	64	66	0	-	-	394.000000	8.000000	112.000000	0.000000	0	0
28	178	152	0	-	-	295.000000	8.000000	110.000000	0.000000	0	0
280	244	484	0	-	-	1488.000000	10.000000	118.000000	0.000000	0	0
282	76	78	0	-	-	430.000000	6.000000	119.000000	0.000000	0	0
284	78	80	0	-	-	214.000000	4.000000	105.000000	0.000000	0	0
286	72	74	0	-	-	414.000000	6.000000	119.000000	0.000000	0	0
288	30	66	0	-	-	420.000000	4.000000	112.000000	0.000000	0	0
290	18	20	0	-	-	832.000000	10.000000	122.000000	0.000000	0	0
292	82	78	0	-	-	253.000000	10.000000	122.000000	0.000000	0	0
294	78	74	0	-	-	267.000000	10.000000	122.000000	0.000000	0	0
296	74	66	0	-	-	292.000000	10.000000	122.000000	0.000000	0	0
298	104	296	0	-	-	772.000000	6.000000	105.000000	0.000000	0	0
30	150	152	0	-	-	550.000000	6.000000	105.000000	0.000000	0	0
300	66	68	0	-	-	189.000000	10.000000	110.000000	0.000000	0	0
302	68	250	0	-	-	401.000000	10.000000	110.000000	0.000000	0	0
304	250	20	0	-	-	385.000000	10.000000	110.000000	0.000000	0	0
306	282	20	0	-	-	559.000000	10.000000	110.000000	0.000000	0	0
308	280	250	0	-	-	674.000000	6.000000	105.000000	0.000000	0	0
310	68	70	0	-	-	286.000000	4.000000	105.000000	0.000000	0	0
312	282	252	0	-	-	254.000000	10.000000	110.000000	0.000000	0	0
314	168	316	0	-	-	487.000000	10.000000	113.000000	0.000000	0	0
316	252	280	0	-	-	310.000000	6.000000	105.000000	0.000000	0	0
318	252	272	0	-	-	121.000000	10.000000	110.000000	0.000000	0	0
32	152	154	0	-	-	522.000000	6.000000	105.000000	0.000000	0	0
322	272	274	0	-	-	363.000000	10.000000	110.000000	0.000000	0	0
324	276	274	0	-	-	264.000000	10.000000	110.000000	0.000000	0	0
326	278	276	0	-	-	279.000000	10.000000	110.000000	0.000000	0	0
328	294	278	0	-	-	288.000000	10.000000	113.000000	0.000000	0	0
330	20	322	0	-	-	1516.000000	10.000000	110.000000	0.000000	0	0
332	322	334	0	-	-	414.000000	10.000000	100.000000	0.000000	0	0
334	258	256	0	-	-	582.000000	8.000000	105.000000	0.000000	0	0
336	258	274	0	-	-	363.000000	6.000000	105.000000	0.000000	0	0
338	258	264	0	-	-	163.000000	8.000000	105.000000	0.000000	0	0
34	180	182	0	-	-	1185.000000	8.000000	110.000000	0.000000	0	0
340	276	264	0	-	-	215.000000	8.000000	105.000000	0.000000	0	0
342	264	262	0	-	-	145.000000	8.000000	105.000000	0.000000	0	0
344	260	262	0	-	-	333.000000	4.000000	105.000000	0.000000	0	0
346	262	268	0	-	-	218.000000	8.000000	105.000000	0.000000	0	0
348	266	268	0	-	-	274.000000	8.000000	105.000000	0.000000	0	0
350	268	270	0	-	-	210.000000	6.000000	105.000000	0.000000	0	0
352	286	288	0	-	-	243.000000	8.000000	105.000000	0.000000	0	0
354	288	290	0	-	-	324.000000	8.000000	105.000000	0.000000	0	0
356	290	292	0	-	-	194.000000	8.000000	105.000000	0.000000	0	0
358	294	292	0	-	-	332.000000	8.000000	105.000000	0.000000	0	0
36	152	144	0	-	-	298.000000	8.000000	105.000000	0.000000	0	0
360	292	300	0	-	-	173.000000	8.000000	105.000000	0.000000	0	0
362	300	298	0	-	-	318.000000	6.000000	105.000000	0.000000	0	0
364	298	296	0	-	-	330.000000	6.000000	105.000000	0.000000	0	0
366	300	302	0	-	-	242.000000	6.000000	105.000000	0.000000	0	0
368	294	308	0	-	-	598.000000	10.000000	110.000000	0.000000	0	0
370	308	314	0	-	-	348.000000	10.000000	113.000000	0.000000	0	0
372	306	308	0	-	-	487.000000	6.000000	108.000000	0.000000	0	0
374	306	304	0	-	-	360.000000	8.000000	108.000000	0.000000	0	0
376	306	312	0	-	-	126.000000	8.000000	108.000000	0.000000	0	0
378	312	310	0	-	-	440.000000	8.000000	108.000000	0.000000	0	0
38	142	144	0	-	-	275.000000	8.000000	105.000000	0.000000	0	0
380	312	314	0	-	-	236.000000	8.000000	108.000000	0.000000	0	0
382	314	320	0	-	-	453.000000	10.000000	113.000000	0.000000	0	0
384	320	316	0	-	-	140.000000	10.000000	113.000000	0.000000	0	0
388	320	430	0	-	-	787.000000	10.000000	130.000000	0.000000	0	0
390	430	432	0	-	-	580.000000	10.000000	130.000000	0.000000	0	0
392	432	434	0	-	-	488.000000	10.000000	130.000000	0.000000	0	0
394	432	436	0	-	-	182.000000	6.000000	130.000000	0.000000	0	0
396	430	442	0	-	-	435.000000	10.000000	130.000000	0.000000	0	0
398	442	448	0	-	-	257.000000	10.000000	130.000000	0.000000	0	0
4	196	198	0	-	-	446.000000	8.000000	118.000000	0.000000	0	0
40	144	146	0	-	-	307.000000	8.000000	105.000000	0.000000	0	0
400	448	456	0	-	-	296.000000	10.000000	130.000000	0.000000	0	0
402	456	464	0	-	-	257.000000	10.000000	130.000000	0.000000	0	0
404	464	472	0	-	-	301.000000	10.000000	130.000000	0.000000	0	0
406	442	440	0	-	-	296.000000	4.000000	130.000000	0.000000	0	0
408	442	444	0	-	-	597.000000	6.000000	130.000000	0.000000	0	0
410	444	450	0	-	-	248.000000	6.000000	130.000000	0.000000	0	0
412	438	436	0	-	-	503.000000	6.000000	130.000000	0.000000	0	0
414	434	438	0	-	-	158.000000	8.000000	130.000000	0.000000	0	0
416	438	452	0	-	-	254.000000	8.000000	130.000000	0.000000	0	0
418	452	460	0	-	-	249.000000	8.000000	130.000000	0.000000	0	0
42	146	148	0	-	-	749.000000	8.000000	105.000000	0.000000	0	0
420	460	468	0	-	-	254.000000	8.000000	130.000000	0.000000	0	0
422	468	478	0	-	-	501.000000	8.000000	130.000000	0.000000	0	0
424	448	446	0	-	-	257.000000	4.000000	130.000000	0.000000	0	0
426	448	450	0	-	-	557.000000	6.000000	130.000000	0.000000	0	0
428	452	450	0	-	-	642.000000	6.000000	130.000000	0.000000	0	0
430	458	450	0	-	-	240.000000	6.000000	130.000000	0.000000	0	0
432	454	462	0	-	-	274.000000	6.000000	130.000000	0.000000	0	0
434	456	454	0	-	-	452.000000	6.000000	130.000000	0.000000	0	0
436	456	458	0	-	-	534.000000	6.000000	130.000000	0.000000	0	0
438	460	458	0	-	-	606.000000	6.000000	130.000000	0.000000	0	0
44	154	146	0	-	-	300.000000	6.000000	108.000000	0.000000	0	0
440	464	462	0	-	-	568.000000	6.000000	130.000000	0.000000	0	0
442	464	466	0	-	-	516.000000	6.000000	130.000000	0.000000	0	0
444	468	466	0	-	-	501.000000	6.000000	130.000000	0.000000	0	0
446	474	466	0	-	-	191.000000	6.000000	130.000000	0.000000	0	0
448	470	462	0	-	-	244.000000	6.000000	130.000000	0.000000	0	0
450	472	470	0	-	-	684.000000	6.000000	130.000000	0.000000	0	0
452	472	474	0	-	-	516.000000	6.000000	130.000000	0.000000	0	0
454	476	484	0	-	-	394.000000	10.000000	130.000000	0.000000	0	0
456	472	476	0	-	-	228.000000	10.000000	130.000000	0.000000	0	0
458	476	478	0	-	-	922.000000	10.000000	130.000000	0.000000	0	0
46	140	142	0	-	-	436.000000	6.000000	105.000000	0.000000	0	0
460	478	480	0	-	-	106.000000	10.000000	130.000000	0.000000	0	0
464	486	478	0	-	-	573.000000	8.000000	130.000000	0.000000	0	0
466	484	486	0	-	-	930.000000	12.000000	130.000000	0.000000	0	0
468	486	490	0	-	-	1621.000000	12.000000	130.000000	0.000000	0	0
470	330	328	0	-	-	181.000000	4.000000	100.000000	0.000000	0	0
472	330	338	0	-	-	454.000000	6.000000	100.000000	0.000000	0	0
474	338	340	0	-	-	432.000000	6.000000	100.000000	0.000000	0	0
476	324	338	0	-	-	311.000000	4.000000	100.000000	0.000000	0	0
478	326	324	0	-	-	227.000000	6.000000	105.000000	0.000000	0	0
48	134	142	0	-	-	233.000000	8.000000	105.000000	0.000000	0	0
480	330	326	0	-	-	309.000000	6.000000	105.000000	0.000000	0	0
482	330	334	0	-	-	169.000000	10.000000	100.000000	0.000000	0	0
484	334	336	0	-	-	169.000000	10.000000	100.000000	0.000000	0	0
486	336	332	0	-	-	282.000000	4.000000	90.000000	0.000000	0	0
488	336	346	0	-	-	342.000000	10.000000	100.000000	0.000000	0	0
490	346	344	0	-	-	165.000000	4.000000	90.000000	0.000000	0	0
492	278	340	0	-	-	383.000000	8.000000	100.000000	0.000000	0	0
494	340	342	0	-	-	342.000000	8.000000	100.000000	0.000000	0	0
496	342	350	0	-	-	435.000000	8.000000	92.000000	0.000000	0	0
498	336	342	0	-	-	872.000000	10.000000	100.000000	0.000000	0	0
50	132	134	0	-	-	354.000000	6.000000	105.000000	0.000000	0	0
500	348	350	0	-	-	475.000000	8.000000	92.000000	0.000000	0	0
5018D	5018_ND	SURGETANK5018	1	5018	-	1.000000	12.000000	150.000000	0.000000	0	0
5018U	28	5018_NU	2	-	5018	1.000000	12.000000	150.000000	0.000000	0	0
502	346	348	0	-	-	377.000000	8.000000	92.000000	0.000000	0	0
5020D	5020_ND	SURGETANK5020	1	5020	-	1.000000	12.000000	150.000000	0.000000	0	0
5020U	284	5020_NU	2	-	5020	1.000000	12.000000	150.000000	0.000000	0	0
5025D	5025_ND	SURGETANK5025	1	5025	-	1.000000	12.000000	150.000000	0.000000	0	0
5025U	318	5025_NU	2	-	5025	1.000000	12.000000	150.000000	0.000000	0	0
5028D	5028_ND	480	1	5028	-	1.000000	12.000000	150.000000	0.000000	0	0
5028U	482	5028_NU	2	-	5028	1.000000	12.000000	150.000000	0.000000	0	0
504	346	354	0	-	-	386.000000	10.000000	100.000000	0.000000	0	0
506	354	358	0	-	-	374.000000	10.000000	100.000000	0.000000	0	0
508	358	364	0	-	-	208.000000	10.000000	100.000000	0.000000	0	0
510	354	352	0	-	-	169.000000	4.000000	94.000000	0.000000	0	0
512	354	356	0	-	-	789.000000	6.000000	96.000000	0.000000	0	0
514	358	360	0	-	-	699.000000	8.000000	100.000000	0.000000	0	0
516	364	362	0	-	-	671.000000	10.000000	100.000000	0.000000	0	0
518	366	364	0	-	-	241.000000	10.000000	100.000000	0.000000	0	0
52	134	136	0	-	-	475.000000	6.000000	105.000000	0.000000	0	0
520	366	368	0	-	-	364.000000	12.000000	100.000000	0.000000	0	0
522	406	366	0	-	-	738.000000	10.000000	100.000000	0.000000	0	0
524	406	408	0	-	-	274.000000	10.000000	100.000000	0.000000	0	0
526	368	370	0	-	-	236.000000	12.000000	100.000000	0.000000	0	0
528	370	410	0	-	-	792.000000	8.000000	100.000000	0.000000	0	0
530	408	410	0	-	-	357.000000	8.000000	100.000000	0.000000	0	0
534	350	356	0	-	-	652.000000	8.000000	100.000000	0.000000	0	0
536	356	360	0	-	-	310.000000	8.000000	100.000000	0.000000	0	0
538	350	376	0	-	-	301.000000	8.000000	100.000000	0.000000	0	0
54	136	138	0	-	-	856.000000	6.000000	105.000000	0.000000	0	0
540	342	374	0	-	-	313.000000	10.000000	100.000000	0.000000	0	0
542	294	372	0	-	-	169.000000	8.000000	108.000000	0.000000	0	0
544	372	374	0	-	-	690.000000	8.000000	125.000000	0.000000	0	0
546	374	376	0	-	-	436.000000	10.000000	125.000000	0.000000	0	0
548	376	378	0	-	-	287.000000	10.000000	125.000000	0.000000	0	0
550	374	380	0	-	-	464.000000	8.000000	125.000000	0.000000	0	0
552	380	392	0	-	-	480.000000	8.000000	125.000000	0.000000	0	0
554	392	396	0	-	-	340.000000	8.000000	125.000000	0.000000	0	0
556	314	394	0	-	-	350.000000	10.000000	122.000000	0.000000	0	0
558	394	396	0	-	-	678.000000	10.000000	122.000000	0.000000	0	0
56	154	156	0	-	-	420.000000	6.000000	108.000000	0.000000	0	0
560	378	384	0	-	-	283.000000	10.000000	130.000000	0.000000	0	0
562	384	388	0	-	-	274.000000	10.000000	130.000000	0.000000	0	0
564	388	398	0	-	-	289.000000	10.000000	130.000000	0.000000	0	0
566	382	384	0	-	-	262.000000	6.000000	130.000000	0.000000	0	0
568	388	386	0	-	-	245.000000	6.000000	130.000000	0.000000	0	0
570	388	390	0	-	-	306.000000	6.000000	130.000000	0.000000	0	0
572	396	400	0	-	-	225.000000	6.000000	119.000000	0.000000	0	0
574	400	402	0	-	-	723.000000	6.000000	119.000000	0.000000	0	0
576	402	422	0	-	-	570.000000	6.000000	119.000000	0.000000	0	0
578	396	398	0	-	-	935.000000	10.000000	115.000000	0.000000	0	0
58	134	130	0	-	-	293.000000	8.000000	105.000000	0.000000	0	0
580	398	412	0	-	-	584.000000	10.000000	115.000000	0.000000	0	0
582	402	398	0	-	-	266.000000	6.000000	119.000000	0.000000	0	0
584	422	412	0	-	-	268.000000	6.000000	105.000000	0.000000	0	0
586	406	404	0	-	-	295.000000	6.000000	100.000000	0.000000	0	0
588	412	404	0	-	-	812.000000	6.000000	100.000000	0.000000	0	0
590	412	414	0	-	-	305.000000	10.000000	110.000000	0.000000	0	0
592	408	416	0	-	-	468.000000	10.000000	100.000000	0.000000	0	0
594	416	414	0	-	-	146.000000	10.000000	100.000000	0.000000	0	0
596	414	420	0	-	-	169.000000	10.000000	110.000000	0.000000	0	0
598	420	424	0	-	-	579.000000	12.000000	110.000000	0.000000	0	0
6	196	194	0	-	-	278.000000	6.000000	118.000000	0.000000	0	0
60	130	118	0	-	-	513.000000	8.000000	105.000000	0.000000	0	0
600	416	418	0	-	-	518.000000	6.000000	105.000000	0.000000	0	0
602	418	424	0	-	-	314.000000	6.000000	105.000000	0.000000	0	0
604	424	426	0	-	-	175.000000	12.000000	110.000000	0.000000	0	0
606	426	428	0	-	-	798.000000	12.000000	110.000000	0.000000	0	0
62	118	94	0	-	-	387.000000	8.000000	105.000000	0.000000	0	0
64	130	128	0	-	-	367.000000	6.000000	105.000000	0.000000	0	0
66	128	122	0	-	-	249.000000	6.000000	105.000000	0.000000	0	0
68	122	116	0	-	-	281.000000	6.000000	105.000000	0.000000	0	0
70	116	118	0	-	-	437.000000	6.000000	105.000000	0.000000	0	0
72	118	120	0	-	-	238.000000	6.000000	105.000000	0.000000	0	0
74	92	94	0	-	-	540.000000	6.000000	105.000000	0.000000	0	0
76	94	88	0	-	-	239.000000	8.000000	105.000000	0.000000	0	0
78	88	90	0	-	-	233.000000	6.000000	105.000000	0.000000	0	0
8	192	190	0	-	-	436.000000	8.000000	118.000000	0.000000	0	0
80	88	86	0	-	-	413.000000	6.000000	105.000000	0.000000	0	0
82	32	84	0	-	-	495.000000	4.000000	100.000000	0.000000	0	0
832	490	428	0	-	-	801.000000	12.000000	100.000000	0.000000	0	0
84	36	88	0	-	-	537.000000	8.000000	105.000000	0.000000	0	0
86	32	34	0	-	-	254.000000	8.000000	100.000000	0.000000	0	0
88	34	36	0	-	-	269.000000	8.000000	100.000000	0.000000	0	0
90	36	38	0	-	-	260.000000	6.000000	97.000000	0.000000	0	0
92	38	40	0	-	-	270.000000	6.000000	97.000000	0.000000	0	0
94	40	42	0	-	-	266.000000	6.000000	97.000000	0.000000	0	0
96	36	42	0	-	-	589.000000	8.000000	100.000000	0.000000	0	0
98	24	34	0	-	-	472.000000	6.000000	97.000000	0.000000	0	0
P11	SURGETANK5025	316	0	-	-	1.000000	12.000000	150.000000	0.000000	0	0
P13	SURGETANK5020	272	0	-	-	1.000000	12.000000	150.000000	0.000000	0	0
P15	SURGETANK5018	12	0	-	-	1.000000	12.000000	150.000000	0.000000	0	0
~$$_UDF_LP_0_0	~$$_UDF_CN_0_0	~$$_UDF_HN_0_0   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_0_0	~$$_UDF_HN_0_0	~$$_UDF_CN_0_0   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_LP_0_1	~$$_UDF_CN_0_1	~$$_UDF_HN_0_1   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_0_1	~$$_UDF_HN_0_1	~$$_UDF_CN_0_1   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_LP_0_2	~$$_UDF_CN_0_2	~$$_UDF_HN_0_2   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_0_2	~$$_UDF_HN_0_2	~$$_UDF_CN_0_2   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_LP_1_0	~$$_UDF_CN_1_0	~$$_UDF_HN_1_0   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_1_0	~$$_UDF_HN_1_0	~$$_UDF_CN_1_0   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_LP_1_1	~$$_UDF_CN_1_1	~$$_UDF_HN_1_1   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_1_1	~$$_UDF_HN_1_1	~$$_UDF_CN_1_1   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_LP_1_2	~$$_UDF_CN_1_2	~$$_UDF_HN_1_2   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_1_2	~$$_UDF_HN_1_2	~$$_UDF_CN_1_2   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_LP_2_0	~$$_UDF_CN_2_0	~$$_UDF_HN_2_0   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_2_0	~$$_UDF_HN_2_0	~$$_UDF_CN_2_0   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_LP_2_1	~$$_UDF_CN_2_1	~$$_UDF_HN_2_1   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_2_1	~$$_UDF_HN_2_1	~$$_UDF_CN_2_1   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_LP_2_2	~$$_UDF_CN_2_2	~$$_UDF_HN_2_2   0   -  -   1.0   100.0   50.0   0.0   0   0
~$$_UDF_SP_2_2	~$$_UDF_HN_2_2	~$$_UDF_CN_2_2   0   -  -   1.0   100.0   50.0   0.0   0   0

[PUMPS]
5018	5018_NU	5018_ND	1	12.000000	0.000000	0.000000	210.600000	1458.000000	0.000000	0.000000	-	-
5020	5020_NU	5020_ND	1	12.000000	0.000000	0.000000	237.900000	1335.000000	0.000000	0.000000	-	-
5025	5025_NU	5025_ND	1	12.000000	0.000000	0.000000	250.500000	940.000000	0.000000	0.000000	-	-
5028	5028_NU	5028_ND	1	12.000000	0.000000	0.000000	210.000000	1000.000000	0.000000	0.000000	-	-

[VALVES]

[PATTERNS]
1	1.575000	1.575000	1.780000	1.780000	1.906000	2.212000
1	2.419000	2.393000	2.094000	1.825000	1.586000	1.431000
1	1.185000	1.185000	1.185000	1.185000	1.320000	1.757000
1	1.686000	1.864000	1.710000	1.710000	1.556000	1.556000
2	0.040000	0.040000	0.040000	0.040000	0.040000	0.040000
2	0.040000	0.040000	0.060000	0.060000	0.060000	0.060000
2	0.090000	0.090000	0.090000	0.090000	0.090000	0.090000
2	0.060000	0.060000	0.060000	0.060000	0.060000	0.060000
3	0.000000	0.000000	0.000000	0.000000	0.000000	0.000000
3	0.000000	0.000000	0.000000	50.000000	50.000000	50.000000
3	50.000000	50.000000	0.000000	0.000000	0.000000	0.000000
3	0.000000	0.000000	0.000000	0.000000	0.000000	0.000000
4	0.000000	0.000000	0.000000	0.000000	0.000000	0.000000
4	0.000000	1.000000	1.000000	1.000000	0.000000	0.000000
4	0.000000	0.000000	0.000000	0.000000	0.000000	0.000000
4	0.000000	0.000000	0.000000	0.000000	0.000000	0.000000

[Pattern_Property]

[CURVES]
1	0.000000	50.000000
1	200.000000	55.000000
1	400.000000	60.000000
1	600.000000	65.000000
1	800.000000	70.000000
1	1000.000000	75.000000
1	1200.000000	80.000000
1	1400.000000	75.000000
1	1800.000000	70.000000
1	2200.000000	65.000000
3	0.000000	50.000000
3	2000.000000	80.000000
3	3000.000000	72.000000
GATEVALVE	10.000000	309.513006
GATEVALVE	20.000000	78.175802
GATEVALVE	30.000000	35.329088
GATEVALVE	40.000000	20.373141
GATEVALVE	50.000000	13.481413
GATEVALVE	60.000000	9.774960
GATEVALVE	70.000000	7.585163
GATEVALVE	80.000000	6.229468
GATEVALVE	90.000000	5.396079
GATEVALVE	100.000000	5.000000
HYDRANTOFF	0.000000	15.750000
HYDRANTOFF	4.000000	15.750000
HYDRANTOFF	10.000000	3150.000000
HYDRANTOFF	60.000000	3150.000000
HYDRANTOFF	65.000000	15.750000
PRESSURE-DEMAND	0.000000	0.000000
PRESSURE-DEMAND	10.000000	100.000000
PRESSURE-DEMAND	50.000000	100.000000
SHUTDOWN	0.000000	1.000000
SHUTDOWN	2.000000	0.000000
SHUTDOWN	4.000000	0.000000
VALVECLOSURE	0.000000	100.000000
VALVECLOSURE	2.000000	100.000000
VALVECLOSURE	5.000000	0.000000
VALVECURVE	10.000000	40852.373293
VALVECURVE	20.000000	2584.697938
VALVECURVE	30.000000	520.204996
VALVECURVE	40.000000	169.418480
VALVECURVE	50.000000	72.042499
VALVECURVE	60.000000	36.375715
VALVECURVE	70.000000	20.732049
VALVECURVE	80.000000	12.944087
VALVECURVE	90.000000	8.684691
VALVECURVE	100.000000	6.180556

[STATUS]
5028	Closed

[CONTROLS]

[EMITTERS]

[TIMES]
DURATION 24.000000 Hours
HYDRAULIC TIMESTEP 2.000000 Hours
PATTERN TIMESTEP 1.000000 Hours
QUALITY TIMESTEP 1.000000 Hours
REPORT TIMESTEP 1.000000 Hours
Pattern Start 0.000000 Hours
REPORT START 0.000000 Hours

[OPTIONS]
UNITS GPM
Pressure psi
HEADLOSS H-W
VISCOSITY 1
DIFFUSIVITY 1
SPECIFIC GRAVITY 1.000000
VAPOR PRESSURE 0.840000
PATTERN TYPE STEPWISE
Emitter Exponent  0.500000
Pressure Dependent Demand No
TRIALS 20
ACCURACY 0.005
Unbalanced  Stop
CHECKFREQ 2
MAXCHECK 10
DAMPLIMIT 0.000000
Relaxation Factor 1.000000
QUALITY Chlorine mg/L
Tolerance  0.001000
Energy Run Yes


[End]
